# Repository a950523a/TES-Taiwan-Electric-Scooter-Charging-Controller

File README.md:

# TES-0D-02-01 DC Charger Controller

> 專為 TES-0D-02-01 標準設計的開源電動機車直流充電控制器。  
> 基於 ESP32-S3，使用 ESP-IDF 原生開發，支援 Web UI 監控、REST API 及 OTA 無線更新。

---

> 🛒 **現成品與服務**：iE125 原廠充電器改裝、TES 快充控制板 —— 見 **[海龜電能官網](https://a950523a.github.io/)**。

---

## ⚠️ 免責聲明與安全警告

**本專案公開「控制板」的韌體與原理圖，不包含功率級電源模組；電路板 layout、BOM 與生產檔不公開。**

1. **高壓危險**：本控制器需配合高壓直流電源使用，組裝與測試過程存在觸電與火災風險。
2. **非商業產品**：本專案為個人研究與技術驗證性質，未經 BSMI、UL 等安規認證。
3. **責任歸屬**：使用本專案所產生的任何後果（包括但不限於車輛損壞、電池故障、人身傷害），**使用者需自行承擔**。若不具備相關電學知識，請勿嘗試製作。
4. **BMS 風險**：CAN Bus 線路若接線錯誤或短路，**將導致車輛 BMS 永久性損壞**，請務必在低壓環境確認無誤後再上機。

---

## 🎯 專案範圍

本 Repository 專注於 **TES 協議控制邏輯** 的實作。

- **包含**：ESP32-S3 控制韌體、CAN Bus 通訊、狀態機邏輯、Web UI、OTA 更新
- **不包含**：功率級整流器、AC/DC 電源模組的控制碼（請依據選用的電源模組自行適配）

---

## ✨ 功能特點

### 核心協議
- **TES 標準相容**：完整實作 TES-0D-02-01 充電通訊協議（0x500/501/508/509/5F0/5F8）
- **寬範圍支援**：最高支援 120V / 100A (12 kW)
- **通用性**：適用於 eMoving iE125 ZAU ES-2000 等支援 TES 快充標準之車輛

### 智慧功能
- **Web UI / PWA**：內建單頁應用，1 秒即時更新電壓、電流、SOC、剩餘時間；可安裝至手機桌面
- **REST API**：`GET /status`、`POST /start`、`POST /stop`、`POST /ota`
- **mDNS**：連接 WiFi 後可用 `http://tes-charger.local` 直接存取
- **OTA 無線更新**：Web UI 一鍵從 GitHub Releases 拉取最新韌體，自動重刷
- **MQTT 遠端監控**：設定 broker 後可在任何網路環境即時監控並遠端 Start/Stop
- **Cloud PWA**：無需與設備在同一個 WiFi，透過 MQTT 遠端監控 👉 [monitor.html](https://a950523a.github.io/TES-Taiwan-Electric-Scooter-Charging-Controller/monitor.html)
- **推播通知**：充電開始／完成／故障時自動透過 ntfy 或 Webhook 推播到手機
- **充電紀錄**：最近 20 次充電的時長、電量 (Wh)、SOC 起訖、停止原因
- **OLED 狀態顯示**：SSD1306 128×64，顯示充電狀態、電壓電流、SOC、剩餘時間
- **設定選單**：長按 SETTING 進入，可調最大電壓、電流、目標 SOC、WiFi 設定
- **LuxBeacon**：LED SOC 脈衝燈號編碼

### 架構特點（V3 重構）
- **純 C99 狀態機**（`tes_protocol/`）：零平台依賴，可移植至 STM32 或 PC 單元測試
- **HAL 抽象層**：硬體相關程式碼全部隔離在 `charger_hal/` 和 `drivers/`
- **GitHub Actions CI/CD**：推送 tag 自動編譯並建立 Release

---

## 🚀 安裝韌體

### 方法一：瀏覽器一鍵燒錄（推薦，無需安裝任何工具）

使用 Chrome 或 Edge，前往 👉 **[GitHub Pages 燒錄工具](https://a950523a.github.io/TES-Taiwan-Electric-Scooter-Charging-Controller/)**

USB 連接主板，點「開始安裝」，全程自動完成（約 30–60 秒）。

### 方法二：命令列燒錄

從 [Releases](https://github.com/a950523a/TES-Taiwan-Electric-Scooter-Charging-Controller/releases/latest) 下載 `tes_charger_flash.bin`：

```bash
esptool.py --chip esp32s3 -p <PORT> write_flash 0x0 tes_charger_flash.bin
```

### 方法三：OTA 更新（已有 V3 韌體）

連線至設備 Web UI → 點「更新至最新韌體」→ 自動從 GitHub Releases 下載並重刷。

---

## 📶 初次設定 WiFi

燒錄完成後：

1. 用手機或電腦連接 WiFi：`TES-Charger`（無密碼）
2. 瀏覽器開啟 `http://192.168.4.1`
3. 在「設定」填入家用 WiFi SSID 與密碼 → 儲存
4. 重啟後自動連接，之後使用 `http://tes-charger.local`

---

## 📱 遠端監控

### 裝置端 PWA（同一個 WiFi）

連線至 `http://tes-charger.local`，點瀏覽器「加入主畫面」即可安裝為 PWA。

### Cloud PWA（任何網路）

👉 **[https://a950523a.github.io/.../monitor.html](https://a950523a.github.io/TES-Taiwan-Electric-Scooter-Charging-Controller/monitor.html)**

需先在裝置端 Web UI 設定 MQTT Broker（建議使用免費公共 broker：`mqtt://broker.hivemq.com:1883`）。
設定後點「取得遠端監控連結」，掃描 QR code 或複製連結，在任何地點開啟即可即時監控並遠端 Start/Stop。

---

## 🕹️ 操作說明

| 按鈕 | 待機 | 選單導覽 | 選單編輯 |
|------|------|----------|----------|
| START | 開始充電 | 上一項 | 微調 +0.1 / 長按 +1 |
| STOP | 停止充電 | 下一項 | 微調 −0.1 / 長按 −1 |
| SETTING 短按 | 循環 SOC 預設 (80→95→100%) | 確認 / 進入編輯 | 確認，回到導覽 |
| SETTING 長按 | 開啟設定選單 | — | — |
| EMERGENCY | 緊急停止（任何狀態有效） | 同左 | 同左 |

---

## 🛠️ 硬體設計

- **原理圖**：[`docs/schematic/TES_Controller_V1.3_schematic.pdf`](docs/schematic/TES_Controller_V1.3_schematic.pdf)（V1.3，供了解電路與維修參考）
- **主要元件**：ESP32-S3 N16R8、ADS1115、SSD1306 OLED、CAN Transceiver、繼電器模組
- **電路板 layout、BOM、生產檔與外殼**：不公開。成品請見上方海龜電能的產品連結。

---

## 💻 開發環境（ESP-IDF）

ESP-IDF 版本固定為 **v5.5.5**，與 CI 相同。版本不一致時，本機解出的當機位址會對不上實際執行的韌體。

```powershell
# 第一次 clone 後先取得子模組（u8g2、tes_protocol、psu_link）
git submodule update --init

# 設定環境（Windows）
$env:IDF_PATH = "C:\Users\<user>\esp\v5.5.5\esp-idf"
# 詳見 CLAUDE.md 完整 PATH 設定

# 編譯
cd firmware
idf.py set-target esp32s3
idf.py build

# 燒錄
idf.py -p <PORT> flash monitor
```

詳細架構說明、任務設計、IPC 機制請參閱 [CLAUDE.md](CLAUDE.md)。

---

## 🤝 社群與支援

- **服務與洽詢**：[海龜電能官網](https://a950523a.github.io/)・[Facebook 粉專](https://www.facebook.com/profile.php?id=61582382523577)（iE125 原廠充電器改裝、TES 快充控制板）
- **Facebook 社群**：[TES 電動機車充電技術交流](https://www.facebook.com/groups/791962053528872/?ref=share&mibextid=NSMWBT)
- **問題回報**：[GitHub Issues](https://github.com/a950523a/TES-Taiwan-Electric-Scooter-Charging-Controller/issues)

---

## ⚖️ 授權

### 著作權

本專案的程式碼與設計檔案採用 **[CC BY-NC-SA 4.0](https://creativecommons.org/licenses/by-nc-sa/4.0/deed.zh_TW)** 授權。

- ✅ 分享與改作：需標示原作者，並以相同條款釋出
- 🚫 禁止商業使用：不得將本專案之設計圖檔、程式碼用於商業量產或販售營利

### 專利權不在本授權範圍內

CC BY-NC-SA 4.0 **只授權著作權，不授權專利權**。這不是本專案額外附加的限制，
而是授權條款本文第 2(b)(2) 節的明文規定（見 [`LICENSE.md`](LICENSE.md) 第 52 行）：

> Patent and trademark rights are not licensed under this Public License.
>
> （本公眾授權條款不授權專利權與商標權。）

因此，依 CC BY-NC-SA 4.0 使用本專案者，僅取得著作權範圍內之授權。**如需商業
使用授權，請另行聯絡作者。**

### 名稱與 Logo

同一條款也不授權商標權：**「海龜電能」名稱與海龜 Logo 不在 CC BY-NC-SA 授權範圍內**，
用於識別作者製作的產品。依本授權重製或改作時，請勿使用它們，避免被誤認為原廠產品。

Copyright (c) 2025-2026 Chris Huang.
All rights not expressly granted under the above license are reserved.

---

## 📌 專案紀錄

| 階段 | 時間 | 內容 |
|---|---|---|
| 專案開始 | 2025-06-19 | Arduino 原型 |
| V2 系列 | 2025-10 ~ 2025-12 | PlatformIO / C++，v2.4.0 ~ v2.5.0-beta |
| **V3 重構** | 2026-05-02 | 改用 ESP-IDF 原生 C99，協定層抽成零相依模組 |
| 遠端監控 | 2026-05 ~ 2026-09 | MQTT、Cloud PWA、排程充電、ESP-NOW PSU 傳輸 |
| 最新釋出 | 2026-09-10 | v3.5.0，**實車驗證完整充電流程** |
| 硬體 V1.3 | 2026-09 | 由 EasyEDA Pro 遷移至 KiCad，改為工具鏈可重現、可驗證 |

技術範圍涵蓋：TES-0D-02-01 協定狀態機、CAN Bus 通訊、即時 FreeRTOS 任務架構、
電源模組控制（UART／ESP-NOW 雙傳輸）、Web UI／REST API／PWA、OTA 更新、
以及 PCB 設計與驗證工具鏈。

作者：**Chris Huang**（[@a950523a](https://github.com/a950523a)）

---

## 🔗 相關專案

- **[TES-Protocol](https://github.com/a950523a/TES-Protocol)**：本專案抽出的可攜式 C99 CAN codec（`tes_types.h` + `tes_codec.c`），可作為 submodule 用於 STM32 或其他平台
- **[LianMing-PSU-Controller](https://github.com/a950523a/LianMing-PSU-Controller)**：聯明電源 CAN Bus 控制器，可與本專案配合使用實現高功率便攜充電方案

---

## 影片

- **1.5 kW / 15 A 充電器實測**：https://youtu.be/JB53_vpZVYo
- **6 kW 研究平台**（控制板＋工業整流模組，轉接汽車 J1772 慢充樁）：https://youtu.be/vA7gSdK1YZQ
- 短片：https://youtube.com/shorts/SKAtfQcCqX8

## 照片

### 成品（V1.2 電路板＋3D 列印外殼）

### 手機監控畫面

> 真實的 Web UI，畫面上的數值是模擬資料。

### V1.3 電路板（KiCad 3D 渲染，尚未生產）

### 開發歷程：2025 年 8 月的洞洞板原型

當時還是 V2 韌體、ESP32 開發板加現成模組；之後改為自行設計 PCB 並換成 ESP32-S3。

## KiCad design hardware/kicad/TES_Controller.kicad_pcb

File hardware/kicad/README.md:

# KiCad 專案（已由 EasyEDA Pro 遷移完成，待出圖）

V1.3 起的硬體設計在 KiCad 進行。EasyEDA Pro 的 V1.3 仍保留在
`docs/PCB/`，並由 `tools/eda_export.py` 匯出成可 diff 的文字檔放在
`hardware/TES_Controller_V1.3/`，作為對照基準。

## 目錄

| 路徑 | 內容 | 進版控 |
|---|---|---|
| `lib/TES.kicad_sym` | 45 個符號：34 個由 BOM 的 LCSC 料號產生、4 個沒有料號的自行產生、6 個電源符號加 PWR_FLAG | ✅ |
| `lib/TES.pretty/` | 32 個封裝（含兩個絲印 logo 與安裝孔，由 `tools/make_logo.py`、`tools/make_mounting_hole.py` 產生） | ✅ |
| `lib/TES.3dshapes/` | 42 個 3D 模型（.step + .wrl） | ❌ **39 MB，已 gitignore** |
| `sym-lib-table` / `fp-lib-table` | 專案層級元件庫設定，開啟專案即生效 | ✅ |

3D 模型是純衍生檔，任何時候都能重新抓。不進版控是因為 `.git` 已經 785 MB，
再塞 39 MB 的二進位進去（而且每次更新元件就是一份全新 blob）划不來。

### 重新產生元件庫

```bash
python tools/kicad_lib.py            # 符號 + 封裝 + 3D
python tools/kicad_lib.py --no-3d    # 只要符號 + 封裝（不需要看 3D 時）
```

需要先建好 venv 並安裝 `easyeda2kicad`，指令寫在 `tools/kicad_lib.py` 檔頭。
腳本會把封裝裡的 3D 路徑改成 `${KIPRJMOD}/lib/TES.3dshapes/...`；
easyeda2kicad 產生的是**絕對路徑**，直接提交會在別台機器上全部失效。

## 沒有 LCSC 料號的元件

這幾個在 EasyEDA 用的是內建通用元件，沒有料號可轉。改成由
`tools/make_symbols.py` / `tools/make_footprints.py` 直接產生，留在同一個
`TES` 庫裡，不必混用 KiCad 內建庫：

| 位號 | EasyEDA 元件 | 現在的符號 |
|---|---|---|
| `D6` `D7` `D8` | led_th-r_5mm | `TES:LED-5MM` |
| `H1` | hdr-f_2.54_1x4p | `TES:HDR-1X4` |
| `H2` | hdr-f_2.54_1x3p | `TES:HDR-1X3` |
| `W1`–`W4` | 焊盤 | `TES:SOLDERPAD-1P` |

## 遷移狀態

- [x] 元件庫（符號 / 封裝 / 3D）
- [x] 電路圖 —— Altium 中轉匯入不了；先改成由網表機器排版，再改成
      **照原稿座標重畫**（`tools/sch_import_easyeda.py`），版面和 EasyEDA 一致
- [x] 網表驗證：230 條接線對 V1.3 原始網表**零差異**
- [x] ERC：0 條違規
- [x] PCB layout —— 雙層、單面貼片；底層整片接地銅箔，機構座標未動
- [x] DRC：0 錯誤、0 未連接（尚有 167 條絲印／外框重疊類警告）
- [x] 電氣修正 —— R10 耐壓、ADS1115 I²C 準位、120V 間距、降壓板進出各一顆 TVS
- [x] Gerber 出圖（2026-09-29）—— `sh tools/make_fab.sh`，輸出在 `hardware/fab/V1.3/`，含嘉立創 SMT 的 BOM／座標檔。還沒下過單

> START 的去彈跳接點不必改：TS-1187A 的 1、2 腳在封裝內部就是短路的，
> 網表裡 START1.3 和 START1.4 也都接 GND，原本以為的問題不存在。

### 全部重新產生

```bash
sh tools/regen_hw.sh            # 含 3D 模型
sh tools/regen_hw.sh --no-3d    # 不抓 3D，快很多
```

八個步驟都是冪等的 —— 但**冪等指的是結果，不是檔案位元組**：符號和導線的
UUID 每次重新產生都是新的，所以重跑一次 `TES_Controller.kicad_sch` 就會出現
兩千多行的 diff，內容其實只有 UUID 不同。要確認有沒有實質變化，跑
`git diff -- hardware/kicad/TES_Controller.kicad_sch | grep -v uuid`，
或乾脆 `git checkout` 掉。

第 4 步會拿 `kicad-cli sch export netlist` 的結果對
`hardware/TES_Controller_V1.3/netlist.txt` 逐條比對，**有任何一條對不上就失敗** ——
這是整條流程的意義所在：轉檔有沒有漏東西是被驗證的，不是用看的。

第 4 步跑的是 `tools/sch_import_easyeda.py`，不是 `tools/sch_gen.py`。後者是早期
「由網表機器排版」的版本，直接跑會把照原稿重畫的版面蓋掉；它現在的角色是
函式庫（載入元件庫、讀網表、驗證），由前者匯入使用。

### 位號變更

KiCad 把沒有結尾數字的位號視為「未編號」，在 GUI 按一次 Annotate 就會被重新命名。
V1.3 有 9 個這種位號，趁重畫改掉：

| V1.3 | 現在 | 說明 |
|---|---|---|
| `Y` `G` `R` | `D6` `D7` `D8` | LED。`R` 若只補數字會變成 `R1`，和既有電阻撞名 |
| `START` `STOP` `SETTING` `EMERGENCY` | 各加 `1` | 絲印可讀性不變 |
| `BOOT` `EN` | `BOOT1` `EN1` | 同上 |

對照表寫在 `tools/sch_gen.py` 的 `DESIGNATOR_RENAME`，比對網表時會換回原名，
所以驗證仍然是對著 V1.3 的原始資料做的。

### V1.3 新增與變更的元件

`tools/changes_v13.py` 是唯一的來源，每一項都附了理由，電路圖和 PCB 都照它套用：
R10 換值並改接 R33、新增 R33/R34（115 k ×3 串聯的上臂）、R11 換 9.09 k、
U5 改回 3.3 V、D9/D10 兩顆 TVS。這些元件在電路圖上另外擺在圖面下方
「V1.3 新增」區，用標籤接線。

### 網路改名

EasyEDA 自動產生的 `$1N24345` 這類網名沒有意義，已改成 `VOUT_SENSE`、`CP_SENSE`、
`VP_PGATE` 等。對照關係在 `tools/sch_gen.py` 的 `NET_RENAME`，每一條都附了推導依據。

匯入完成後跑設計檢查：

```bash
kicad-cli pcb drc --severity-error --exit-code-violations hardware/kicad/TES_Controller.kicad_pcb
```

DRC **不進 CI** —— 設計檢查是設計當下的工作，不是每次 push 都要跑的東西。

Parts:
BOOT1: TS-1088-AR02016; SW-SMD_L3.9-W3.0-P4.45; MPN TS-1088-AR02016; LCSC Part C720477
C1, C10, C16: 22uF; C1206; MPN CL31A226KAHNNNE; LCSC Part C12891
C2, C7, C8: 1uF; C0603; MPN CL10A105KB8NNNC; LCSC Part C15849
C3, C4, C11, C12, C13, C14, C15, C20, C28, C29: 100nF; C0603; MPN CC0603KRX7R9BB104; LCSC Part C14663
C9, C17: 10uF; C1206; MPN CL31A106KBHNNNE; LCSC Part C13585
CN1: B2PS-VH(LF)(SN); CONN-TH_B2PS-VH-LF-SN; MPN B2PS-VH(LF)(SN); LCSC Part C158007
CN2: S4B-XH-A(LF)(SN); CONN-TH_S4B-XH-A-LF-SN; MPN S4B-XH-A(LF)(SN); LCSC Part C157925
CN3, CN5, CN6: DG381-3.5-02P-14-00A(H); CONN-TH_2P-P3.50_DG381-3.5-02P-14-00A; MPN DG381-3.5-02P-14-00A(H); LCSC Part C5272864
D1, D4: SS14; SMA_L4.2-W2.6-LS5.0-RD_1; MPN SS14; LCSC Part C2480
D3, D10: SMBJ12A; SMB_L4.6-W3.6-LS5.3-RD; MPN SMBJ12A; LCSC Part C908793
D5: USBLC6-2SC6; SOT-23-6_L2.9-W1.6-P0.95-LS2.8-BL; MPN USBLC6-2SC6; LCSC Part C7519
D6, D7, D8: LED-5MM; LED-TH_BD5.8-P2.54-FD
D9: SMBJ130A; SMB_L4.6-W3.6-LS5.3-RD; MPN SMBJ12A; LCSC Part C908793
EMERGENCY1: TS-1187A-B-A-B; SW-SMD_4P-L5.1-W5.1-P3.70-LS6.5-TL_H1.5; MPN TS-1187A-B-A-B; LCSC Part C318884
EN1: TS-1088-AR02016; SW-SMD_L3.9-W3.0-P4.45; MPN TS-1088-AR02016; LCSC Part C720477
H1: HDR-1X4; HDR-TH_4P-P2.54-V-F
H2: HDR-1X3; HDR-TH_3P-P2.54-V-F
Q1, Q2, Q3: AO3400A; SOT-23-3_L2.9-W1.3-P1.90-LS2.4-BR; MPN AO3400A; LCSC Part C20917
Q4: AO3401A; SOT-23_L2.9-W1.3-P1.90-LS2.4-BR; MPN AO3401A; LCSC Part C15127
R1, R5, R6, R17, R20, R26, R28, R32: 10kΩ; R0603; MPN 0603WAF1002T5E; LCSC Part C25804
R2, R3: 5.1kΩ; R0402; MPN 0402WGF5101TCE; LCSC Part C25905
R8: 51Ω; R1206; MPN FRP1206F51R0TS; LCSC Part C7468320
R9: 150Ω; R1210; MPN FRC1210F1500TS; LCSC Part C2933805
R10: RT0603BRE07115KL; R0603; MPN RT0603BRD07348KL; LCSC Part C861336
R11: RT0603BRD079K09L; R0603; MPN RT0603BRD0712KL; LCSC Part C326735
R12: 430Ω; R0603; MPN RC0603FR-07430RL; LCSC Part C137721
R13: 470Ω; R0603; MPN 0603WAF4700T5E; LCSC Part C23179
R14: 510Ω; R0603; MPN 0603WAF5100T5E; LCSC Part C23193
R16, R19, R29: 100Ω; R0603; MPN 0603WAF1000T5E; LCSC Part C22775
R21: 120Ω; R0603; MPN 0603WAF1200T5E; LCSC Part C22787
R30, R31: 22Ω; R0603; MPN 0603WAF220JT5E; LCSC Part C23345
R33, R34: RT0603BRE07115KL; R0603; MPN 0603WAF1002T5E; LCSC Part C25804
R35, R36, R37: 0603WAF1002T5E; R0603; MPN 0603WAF1002T5E; LCSC Part C25804
SB1: JUMPER SOLDER BRIDGE COPY COPY; R0603; MPN 0603WAF0000T5E; LCSC Part C21189
SETTING1: TS-1187A-B-A-B; SW-SMD_4P-L5.1-W5.1-P3.70-LS6.5-TL_H1.5; MPN TS-1187A-B-A-B; LCSC Part C318884
START1: TS-1187A-B-A-B; SW-SMD_4P-L5.1-W5.1-P3.70-LS6.5-TL_H1.5; MPN TS-1187A-B-A-B; LCSC Part C318884
STOP1: TS-1187A-B-A-B; SW-SMD_4P-L5.1-W5.1-P3.70-LS6.5-TL_H1.5; MPN TS-1187A-B-A-B; LCSC Part C318884
U1: ESP32-S3-WROOM-1-N16R8; WIRELM-SMD_ESP32-S3-WROOM-1; MPN ESP32-S3-WROOM-1-N16R8; LCSC Part C2913202
U5: ADS1115IDGSR; MSOP-10_L3.0-W3.0-P0.50-LS5.0-BL; MPN ADS1115IDGSR; LCSC Part C37593
U6: AMS1117-3.3; SOT-223-3_L6.5-W3.4-P2.30-LS7.0-BR; MPN AMS1117-3.3; LCSC Part C6186
U8: LMZM23601V5SILR; USIP-10_L3.8-W3.0-TL_TI_SIL; MPN LMZM23601V5SILR; LCSC Part C2868357
U10: DG301-5.0-02P-14-00A(H); CONN-TH_DEGSON_DG301-5.0-02P; MPN DG301-5.0-02P-14-00A(H); LCSC Part C5128812
U12: TJA1051T/3/1J; SOIC-8_L4.9-W3.9-P1.27-LS6.0-BL; MPN TJA1051T/3/1J; LCSC Part C38695
USB1: TYPE-C16PIN; USB-C-SMD_TYPE-C16PIN; MPN TYPE-C16PIN; LCSC Part C393939
W1, W2, W3, W4: SOLDERPAD-1P; SOLDERPAD-TH_3.0X1.5

Connections:
5V: C9.1, C16.2, C29.1, SB1.2, U6.3 (VIN), U8.6 (VOUT), U8.7 (FB), U12.3 (VCC)
12V: C17.2, CN3.1, CN5.1, CN6.1, D1.1 (K), D4.1 (K), D10.1 (C), Q4.2 (S), R26.2, U8.3 (VIN), U8.4 (EN), W2.1
120V: D9.1 (C), R10.2, U10.1, W1.1
CANH: CN2.2, R21.1, U12.7 (CANH)
CANL: CN2.1, R21.2, U12.6 (CANL)
COUPLER: CN6.2, D4.2 (A), Q3.3 (D)
COUPLER_GATE: Q3.2 (G), R28.2, R29.2
CP: CN2.4, R9.1
CP_SENSE: C7.1, R8.1, R9.2, U5.6 (AIN2)
D+: R31.2, U1.14 (IO20)
D-: R30.2, U1.13 (IO19)
DC_RELAY: CN3.2, CN5.2, D1.2 (A), Q1.3 (D)
EN: C2.2, C4.1, EN1.2, R1.2, U1.3 (EN)
GND: BOOT1.2, C1.1, C2.1, C3.1, C4.2, C7.2, C9.2, C10.2, C11.1, C12.2, C13.2, C14.2, C15.2, C16.1, C17.1, C20.2, C28.1, C29.2, CN1.1, CN2.3, D3.2 (A), D5.2, D10.2 (A), EMERGENCY1.3 (C), EMERGENCY1.4 (D), EN1.1, H1.1, H2.1, Q1.1 (S), Q2.1 (S), Q3.1 (S), R2.1, R3.1, R8.2, R12.1, R13.1, R14.1, R17.1, R20.1, R28.1, R37.2, SETTING1.3 (C), SETTING1.4 (D), START1.3 (C), START1.4 (D), STOP1.3 (C), STOP1.4 (D), U1.1 (GND), U1.40 (GND), U1.41 (GND), U5.1 (ADDR), U5.3 (GND), U6.1 (GND), U8.1 (GND), U8.2 (MODE_SYNC), U8.11 (EP), U12.2 (GND), U12.8 (S), USB1.1 (SHELL), USB1.2 (SHELL), USB1.3 (SHELL), USB1.4 (SHELL), USB1.A1B12 (GND), USB1.B1A12 (GND), W4.1
GND_BACK: C8.1, D9.2 (A), R11.1, U5.5 (AIN1), U10.2, W3.1
HV_DIV1: R10.1, R33.2
HV_DIV2: R33.1, R34.2
HW_ID: R36.2, R37.1, U5.7 (AIN3)
IO0: BOOT1.1, C11.2, R32.2, U1.27 (IO0)
IO5: D6.1 (A), U1.5 (IO5)
IO6: D7.1 (A), U1.6 (IO6)
IO7: D8.1 (A), U1.7 (IO7)
IO9: R16.1, U1.17 (IO9)
IO10: R29.1, U1.18 (IO10)
IO11: R19.1, U1.19 (IO11)
IO17: U1.10 (IO17), U12.1 (TXD)
IO18: U1.11 (IO18), U12.4 (RXD)
IO39: C12.1, STOP1.2 (B), U1.32 (IO39)
IO40: C14.1, EMERGENCY1.2 (B), U1.33 (IO40)
IO41: C15.1, SETTING1.2 (B), U1.34 (IO41)
IO42: START1.1 (A), U1.35 (IO42)
IO42_DEBOUNCE: C13.1, START1.2 (B)
LED_G_K: D7.2 (K), R14.2
LED_R_K: D8.2 (K), R12.2
LED_Y_K: D6.2 (K), R13.2
RELAY_GATE: Q1.2 (G), R19.2, R20.2
RXD0: H2.3, U1.36 (RXD0)
SCL: H1.3, R5.1, U1.8 (IO15), U5.10 (SCL)
SDA: H1.4, R6.1, U1.9 (IO16), U5.9 (SDA)
TXD0: H2.2, U1.37 (TXD0)
UD+: D5.1, USB1.A6 (DP1), USB1.B6 (DP2)
UD-: D5.3, USB1.A7 (DN1), USB1.B7 (DN2)
USB_CC1: R2.2, USB1.A5 (CC1)
USB_CC2: R3.2, USB1.B5 (CC2)
USB_DN_ESD: D5.4, R30.1
USB_DP_ESD: D5.6, R31.1
VBUS: D5.5, SB1.1, USB1.A4B9 (VBUS), USB1.B4A9 (VBUS)
VDD33: C1.2, C3.2, C10.1, C20.1, C28.2, H1.2, R1.1, R5.2, R6.2, R32.1, R36.1, U1.2 (3V3), U5.8 (VDD), U6.2 (VOUT), U6.4 (VOUT), U12.5 (VIO)
VOUT_SENSE: C8.2, R11.2, R34.1, U5.4 (AIN0)
VP: CN1.2, D3.1 (C), Q4.3 (D)
VP_NGATE: Q2.2 (G), R16.2, R17.2
VP_PGATE: Q4.1 (G), R26.1, R35.1
VP_PGATE_DRV: Q2.3 (D), R35.2

Notes on the sheet:
3.3V LDO
Button
Voltage sensor
CAN Bus
Connector
VP Relay
EN Button
LED
5V Buck
OLED
Upload
V1.3 新增（原 EasyEDA 稿沒有）

Board: 2 copper layers, 64.1 x 89.3 mm, 90 parts (2 on the bottom side), 53 nets.

Other parts of the board:
LOGO1: LOGO_TurtlePower_9mm
LOGO2: LOGO_TurtlePower_20mm
MH1, MH2, MH3, MH4: MountingHole_3.2mm_NPTH_Keepout4.6mm

File hardware/TES_Controller_V1.1/bom.csv:

designator,part,value,device,supplier
BOOT,TS-1088-AR02016,,ts-1088-ar02016,C720477
C1,CL31A226KAHNNNE,22uF,cl31a226kahnnne,C12891
C2,CL10A105KB8NNNC,1uF,cl10a105kb8nnnc,C15849
C3,CC0603KRX7R9BB104,100nF,cc0603krx7r9bb104,C14663
C4,CC0603KRX7R9BB104,100nF,cc0603krx7r9bb104,C14663
C7,CL10A105KB8NNNC,1uF,cl10a105kb8nnnc,C15849
C8,CL10A105KB8NNNC,1uF,cl10a105kb8nnnc,C15849
C9,CL31A106KBHNNNE,10uF,cl31a106kbhnnne,C13585
C10,CL31A226KAHNNNE,22uF,cl31a226kahnnne,C12891
C11,CC0603KRX7R9BB104,100nF,cc0603krx7r9bb104,C14663
C12,CC0603KRX7R9BB104,100nF,cc0603krx7r9bb104,C14663
C13,CC0603KRX7R9BB104,100nF,cc0603krx7r9bb104,C14663
C14,CC0603KRX7R9BB104,100nF,cc0603krx7r9bb104,C14663
C15,CC0603KRX7R9BB104,100nF,cc0603krx7r9bb104,C14663
C16,CL31A226KAHNNNE,22uF,cl31a226kahnnne,C12891
C17,CL31A106KBHNNNE,10uF,cl31a106kbhnnne,C13585
C20,CC0603KRX7R9BB104,100nF,cc0603krx7r9bb104,C14663
C28,CC0603KRX7R9BB104,100nF,cc0603krx7r9bb104,C14663
C29,CC0603KRX7R9BB104,100nF,cc0603krx7r9bb104,C14663
CN1,B2PS-VH(LF)(SN),,b2ps-vh(lf)(sn),C158007
CN2,S4B-XH-A(LF)(SN),,s4b-xh-a(lf)(sn),C157925
CN3,DG381-3.5-02P-14-00A(H),,dg381-3.5-02p-14-00a(h),C5272864
CN5,DG381-3.5-02P-14-00A(H),,dg381-3.5-02p-14-00a(h),C5272864
CN6,DG381-3.5-02P-14-00A(H),,dg381-3.5-02p-14-00a(h),C5272864
D1,SS14,,ss14_c2480,C2480
D3,SMBJ12A,,smbj12a_c908793,C908793
D4,SS14,,ss14_c2480,C2480
D5,USBLC6-2SC6,,usblc6-2sc6_c7519,C7519
EMERGENCY,TS-1187A-B-A-B,,ts-1187a-b-a-b,C318884
EN,TS-1088-AR02016,,ts-1088-ar02016,C720477
G,,,led_th-r_5mm,
H1,,,hdr-f_2.54_1x4p,
H2,,,hdr-m_2.54_1x2p,
Q1,AO3400A,,ao3400a_c20917,C20917
Q2,AO3400A,,ao3400a_c20917,C20917
Q3,AO3400A,,ao3400a_c20917,C20917
Q4,AO3401A,,ao3401a_c15127,C15127
R,,,led_th-r_5mm,
R1,0603WAF1002T5E,10kΩ,0603waf1002t5e,C25804
R2,0402WGF5101TCE,5.1kΩ,0402wgf5101tce,C25905
R3,0402WGF5101TCE,5.1kΩ,0402wgf5101tce,C25905
R5,0603WAF1002T5E,10kΩ,0603waf1002t5e,C25804
R6,0603WAF1002T5E,10kΩ,0603waf1002t5e,C25804
R8,FRP1206F51R0TS,51Ω,frp1206f51r0ts,C7468320
R9,FRC1210F1500TS,150Ω,frc1210f1500ts,C2933805
R10,RT0603BRD07348KL,348kΩ,rt0603brd07348kl,C861336
R11,RT0603BRD0712KL,12kΩ,rt0603brd0712kl,C326735
R12,RC0603FR-07430RL,430Ω,rc0603fr-07430rl,C137721
R13,0603WAF4700T5E,470Ω,0603waf4700t5e,C23179
R14,0603WAF5100T5E,510Ω,0603waf5100t5e,C23193
R16,0603WAF1000T5E,100Ω,0603waf1000t5e,C22775
R17,0603WAF1002T5E,10kΩ,0603waf1002t5e,C25804
R19,0603WAF1000T5E,100Ω,0603waf1000t5e,C22775
R20,0603WAF1002T5E,10kΩ,0603waf1002t5e,C25804
R21,0603WAF1200T5E,120Ω,0603waf1200t5e,C22787
R26,0603WAF1002T5E,10kΩ,0603waf1002t5e,C25804
R28,0603WAF1002T5E,10kΩ,0603waf1002t5e,C25804
R29,0603WAF1000T5E,100Ω,0603waf1000t5e,C22775
R30,0603WAF220JT5E,22Ω,0603waf220jt5e,C23345
R31,0603WAF220JT5E,22Ω,0603waf220jt5e,C23345
SB1,0603WAF0000T5E,Jumper,jumper solder bridge copy copy,C21189
SETTING,TS-1187A-B-A-B,,ts-1187a-b-a-b,C318884
START,TS-1187A-B-A-B,,ts-1187a-b-a-b,C318884
STOP,TS-1187A-B-A-B,,ts-1187a-b-a-b,C318884
U1,ESP32-S3-WROOM-1-N16R8,,esp32-s3-wroom-1-n16r8,C2913202
U5,ADS1115IDGSR,,ads1115idgsr,C37593
U6,AMS1117-3.3,,ams1117-3.3_c6186,C6186
U8,LMZM23601V5SILR,,lmzm23601v5silr,C2868357
U10,DG301-5.0-02P-14-00A(H),,dg301-5.0-02p-14-00a(h),C5128812
U12,TJA1051T/3/1J,,tja1051t/3/1j,C38695
USB1,TYPE-C16PIN,,type-c16pin,C393939
W1,SOLDERPAD-1P,,solder wire pad,
W2,SOLDERPAD-1P,,solder wire pad,
W3,SOLDERPAD-1P,,solder wire pad,
W4,SOLDERPAD-1P,,solder wire pad,
Y,,,led_th-r_5mm,

## Code that names these connections

File tools/changes_v13.py (part):

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        # 自動擺放第一次放在 3.6 mm 外、走線 8 mm 還跨到底層。位號文字隱藏，
        # 和旁邊的 R26、R17、Q4 一樣。
        at=(138.05, 133.30, 90),
        pins={"1": "VP_PGATE", "2": "VP_PGATE_DRV"},
        why="""Q4 的 V_GS 原本踩在絕對最大額定上。這是設計瑕疵，不是餘裕不足。

        原電路：R26（10k）把 Q4 的閘極拉到源極（12V）保持關閉，要導通時
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        # HW_ID 唯一的出口。重新產生 PCB 時這段要照這個路徑再繞一次。
        at=(133.70, 94.10, 180),
        track_width=0.25,
        pins={"1": "VDD33", "2": "HW_ID"},
        why="""硬體版本 ID 分壓的上臂。V1.3 = 第 6 級：R36 = R37 = 10k。

        HW_ID = 3.3 V × R37 / (R36 + R37)。韌體開機時以單端模式讀 AIN3
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        symbol=R_SYMBOL, footprint=R_FOOTPRINT,
        at=(132.30, 91.80, 90),   # C7 正下方；接地腳就近打地孔 (133.20, 91.05)
        track_width=0.25,
        pins={"1": "HW_ID", "2": "GND"},
        why="硬體版本 ID 分壓的下臂（見 R36 的說明與級數表）。",
    ),

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    dict(
        op="add_part", ref="R33", value="RT0603BRE07115KL",
        symbol=R_SYMBOL, footprint=R_FOOTPRINT,
        pins={"1": "HV_DIV2", "2": "HV_DIV1"},
        why="R10 分壓上臂的第二顆（見 R10 的說明）。",
    ),
    dict(
        op="add_part", ref="R34", value="RT0603BRE07115KL",
        symbol=R_SYMBOL, footprint=R_FOOTPRINT,
        pins={"1": "VOUT_SENSE", "2": "HV_DIV2"},
        why="R10 分壓上臂的第三顆，接到分壓中點 VOUT_SENSE（見 R10 的說明）。",
    ),
    dict(
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
## Commit log (part)

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2025-10-17 v2.4.0
    Auto detect voltage
2025-10-18 v2.4.1
    improve WiFi connect logic
2025-10-19 NetworkServices.cpp の更新
2025-11-26 v2.4.1
    improve wifi connect logic ,adjust fast SOC switch default
2025-11-28 v2.4.2
    Add stop condition to avoid overcharging
2025-12-02 V3_beta_dev
2025-12-02 Revert "V3_beta_dev"
    This reverts commit 741472a4042209edc08e2b2c66cf5697eb501529.
2025-12-02 Reapply "V3_beta_dev"
    This reverts commit 10891f9e5e8777a81eff61f0e8de7156053c4ebd.
2025-12-02 Update README to simplify hardware and software sections
    Removed outdated hardware and software dependency instructions.
2025-12-04 dev_backup
2025-12-07 v2.5.0_Beta
    Auto control current
    *Just for testing
2026-01-04 Revise README for project name and details
    Updated README to reflect project name change and added new sections for features, hardware design, and community support.
2026-01-04 Update README with project V2 photo details
    Added a note about the transition to self-designed PCBs and ESP32-S3 development.
2026-01-04 Add additional YouTube link to README
    Added a new YouTube link to the video section.
2026-01-04 Remove subtitle from README.md
    Removed the subtitle for the TES-EVSE Controller.
2026-01-18 Add related projects section to README
    Added a section for related projects with a link to LMPower-CAN-Controller.
2026-05-01 V3 function test
2026-05-01 Basic function OK PSU still debugging
2026-05-01 PSU Bug fixed,Basic function test ok
2026-05-01 Add SOC,Voltage,Current Quick Setting
2026-05-01 Add Network and fix logic bug
2026-05-09 update manual
2026-05-09 Update tes_protocol submodule to f208c64 (add vehicle encode + charger decode functions)

Notices in the files:
README.md:
License: CC BY-NC-SA 4.0
